## src/examples/rw_uart/Kconfig
```kconfig
menuconfig EXAMPLES_RW_UART
 bool "rw_uart"
 default n
 ---help---
     Enable support for rw_uart
```
